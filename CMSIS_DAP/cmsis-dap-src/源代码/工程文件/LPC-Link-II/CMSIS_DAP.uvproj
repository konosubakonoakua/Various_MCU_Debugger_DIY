# Keil uVision project CMSIS_DAP.uvproj, settings and files
target LPC4320 SPIFI (ARM-ADS)
  device: LPC4320 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x20003FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: CMSIS_DAP
  c flags: Optim=4
  c include: .
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\SPIFI.sct
  group Startup Code
    ./: startup_LPC43xx.s system_LPC43xx.c
  group Configuration
    ./: DAP_config.h usb_config_USB0.c
  group USB Driver
    ./: usbd_LPC43xx_USB0.c
  group CMSIS-DAP Core
    ./: main.c usbd_user_hid.c
    ../: DAP.c SW_DP.c JTAG_DP.c
  group Library
    C:/Keil/ARM/RV31/LIB/: USB_CM3.lib
  group Documentation
    ./: Abstract.txt
target LPC4320 RAM (ARM-ADS)
  device: LPC4320 NXP (founded by Philips)
  cpu: as above
  output: CMSIS_DAP
  c flags: Optim=4
  c include: .
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
